<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ili9488_spi.ewp</path>
  </project>
  <batchBuild />
</workspace>
